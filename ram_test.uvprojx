# Keil uVision project ram_test.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MDR32F8 Milandr
  pack: Keil.MDR32F8.0.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x20006000,0x2000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: ram_test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x20006000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group user
    ./: main.c mdr1645ru6u.c mdr1645ru6u.h ram_macros.h mdr1986_rtc.c mdr1986_rtc.h mdr1645_failreport.c mdr1645_failreport.h
software components: CMSIS:CORE 5.1.2, Device:Startup 0.0.1, Drivers:CLKCTRL 0.0.1, Drivers:EBC 0.0.1, Drivers:LIB 0.0.1, Drivers:PORT 0.0.1, Drivers:TIM 0.0.1
